# Our changes
#

RDEPENDS:${PN} = "\
  qtserialport \
  qtbase-mkspecs \
  qtbase-plugins \
"
